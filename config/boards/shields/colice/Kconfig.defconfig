## config/boards/shields/colice/Kconfig.defconfig
```kconfig
if SHIELD_COLICE

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Colice"

endif
```
